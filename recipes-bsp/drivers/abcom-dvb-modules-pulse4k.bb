SRCDATE = "20210324"

require abcom-dvb-modules.inc

SRC_URI[md5sum] = "f7dee919454c1bec210a01a7de53279c"
SRC_URI[sha256sum] = "8ff87b605a19e6a96c449a5d4c2357f4a42182ae3dd5583dd7abca9fa8d76e6b"

COMPATIBLE_MACHINE = "^(pulse4k)$"
